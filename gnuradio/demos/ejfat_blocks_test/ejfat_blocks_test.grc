options:
  parameters:
    author: EJFAT Demos
    description: Test and demonstrate all EJFAT blocks with random data
    generate_options: qt_gui
    hier_block_src_path: .:.
    id: ejfat_blocks_test
    output_language: python
    title: EJFAT Blocks Test & Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: shm_capacity
  id: variable
  parameters:
    comment: Shared memory FIFO capacity
    value: '1024'
  states: {}
- name: shm_entry_size
  id: variable
  parameters:
    comment: Bytes per entry (8 bytes/sample * vlen + metadata)
    value: int(vlen * 8 + 64)
  states: {}
- name: vlen
  id: variable
  parameters:
    comment: Vector length for testing
    value: '1024'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    comment: Random complex samples for SHM test
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '1'
    comment: Random complex samples for E2SAR test
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Convert to vectors for SHM sink
    num_items: vlen
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    comment: Convert to vectors for E2SAR segmenter
    num_items: vlen
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    comment: Convert back to stream for display
    num_items: vlen
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    comment: Convert back to stream for display
    num_items: vlen
    type: complex
  states: {}
- name: ejfat_e2sar_reassembler_source_0
  id: ejfat_e2sar_reassembler_source
  parameters:
    comment: Reassemble EJFAT packets back to vectors
    data_ip: 127.0.0.1
    epoch_ms: '1000'
    event_timeout_ms: '5000'
    kd: '0.0'
    ki: '0.0'
    kp: '0.0'
    max_factor: '2.0'
    min_factor: '0.5'
    num_recv_threads: '1'
    period_ms: '100'
    port_range: '-1'
    rcv_socket_buf_size: '3145728'
    set_point: '0.0'
    starting_port: '19522'
    uri: ejfat://useless@192.168.100.1:9876/lb/1?sync=192.168.0.1:12345&data=127.0.0.1
    use_cp: 'False'
    use_host_address: 'False'
    validate_cert: 'True'
    vector_size: vlen
    weight: '1.0'
    with_lb_header: 'True'
  states: {}
- name: ejfat_e2sar_segmenter_sink_0
  id: ejfat_e2sar_segmenter_sink
  parameters:
    comment: Segment data into EJFAT packets
    data_id: '1'
    event_src_id: '1'
    mtu: '9000'
    rate_gbps: '1.0'
    uri: ejfat://useless@192.168.100.1:9876/lb/1?sync=192.168.0.1:12345&data=127.0.0.1:19522
    use_cp: 'False'
    vector_size: vlen
  states: {}
- name: ejfat_ejfat_shm_sink_0
  id: ejfat_ejfat_shm_sink
  parameters:
    capacity: shm_capacity
    comment: Write vectors to shared memory
    entry_size: shm_entry_size
    shm_name: ejfat_test_fifo
    vlen: vlen
  states: {}
- name: ejfat_ejfat_shm_source_0
  id: ejfat_ejfat_shm_source
  parameters:
    comment: Read vectors from shared memory
    shm_name: ejfat_test_fifo
    timeout: '1.0'
    vlen: vlen
  states: {}
- name: note_e2sar_test
  id: note
  parameters:
    note: 'TEST 2: E2SAR Segmenter/Reassembler (Loopback)'
  states: {}
- name: note_shm_test
  id: note
  parameters:
    note: 'TEST 1: Shared Memory (SHM) Transport'
  states: {}
- name: qtgui_freq_sink_e2sar
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Display E2SAR output spectrum
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@1
    label1: E2SAR Output
    label2: ''
    name: '"E2SAR Test - Frequency"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_shm
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Display SHM output spectrum
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@0
    label1: SHM Output
    name: '"SHM Test - Frequency"'
    type: complex
  states: {}
- name: qtgui_time_sink_e2sar
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Display E2SAR output time domain
    grid: 'True'
    gui_hint: tabs@1
    label1: Real
    label2: Imag
    name: '"E2SAR Test - Time Domain"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_shm
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Display SHM output time domain
    grid: 'True'
    gui_hint: tabs@0
    label1: Real
    label2: Imag
    name: '"SHM Test - Time Domain"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    comment: Organize test results in tabs
    label0: SHM Test
    label1: E2SAR Test
    num_tabs: '2'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [analog_noise_source_x_1, '0', blocks_throttle_1, '0']
- [blocks_stream_to_vector_0, '0', ejfat_ejfat_shm_sink_0, '0']
- [blocks_stream_to_vector_1, '0', ejfat_e2sar_segmenter_sink_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_1, '0', blocks_stream_to_vector_1, '0']
- [blocks_throttle_1, '0', qtgui_freq_sink_e2sar, '1']
- [blocks_throttle_1, '0', qtgui_time_sink_e2sar, '1']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_shm, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_shm, '0']
- [blocks_vector_to_stream_1, '0', qtgui_freq_sink_e2sar, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_e2sar, '0']
- [ejfat_e2sar_reassembler_source_0, '0', blocks_vector_to_stream_1, '0']
- [ejfat_ejfat_shm_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
