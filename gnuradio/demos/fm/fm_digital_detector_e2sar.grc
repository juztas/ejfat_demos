options:
  parameters:
    description: FM receiver with digital sideband detection and E2SAR streaming
    generate_options: qt_gui
    hier_block_src_path: .:.
    id: fm_digital_detector_e2sar
    output_language: python
    title: FM Digital Sideband Detector (SDR to E2SAR)
  states: {}

blocks:
- name: data_id
  id: variable
  parameters:
    comment: E2SAR data ID
    value: '1'
  states: {}
- name: digital_indicator
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_0
    comment: Digital FM indicator for XML-RPC access
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: digital_threshold
  id: variable
  parameters:
    comment: Threshold for digital detection (dB)
    value: '-20'
  states: {}
- name: ejfat_uri
  id: variable
  parameters:
    comment: EJFAT URI for E2SAR connection (direct connection, no LB)
    value: '"ejfat://127.0.0.1:19522/lb/1?data=127.0.0.1:19522"'
  states: {}
- name: energy_avg_len
  id: variable
  parameters:
    comment: Moving average length for energy smoothing
    value: '10000'
  states: {}
- name: event_src_id
  id: variable
  parameters:
    comment: E2SAR event source ID
    value: '1'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: 'Ottawa: 106.1 CHEZ (HD Radio)'
    value: 106.1e6
  states: {}
- name: lower_sideband_center
  id: variable
  parameters:
    comment: HD Radio lower sideband center frequency offset
    value: '-165000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: sideband_bw
  id: variable
  parameters:
    comment: HD Radio sideband bandwidth
    value: '70000'
  states: {}
- name: signal_level
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_1
    comment: Analog FM signal level for XML-RPC access
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: upper_sideband_center
  id: variable
  parameters:
    comment: HD Radio upper sideband center frequency offset
    value: '165000'
  states: {}
- name: vlen
  id: variable
  parameters:
    comment: Vector length - must match receiver
    value: '8192'
  states: {}
- name: band_pass_filter_lower
  id: band_pass_filter
  parameters:
    comment: Lower digital sideband bandpass
    decim: '1'
    gain: '1'
    high_cutoff_freq: lower_sideband_center + sideband_bw/2
    low_cutoff_freq: lower_sideband_center - sideband_bw/2
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_upper
  id: band_pass_filter
  parameters:
    comment: Upper digital sideband bandpass
    decim: '1'
    gain: '1'
    high_cutoff_freq: upper_sideband_center + sideband_bw/2
    low_cutoff_freq: upper_sideband_center - sideband_bw/2
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Convert lower sideband to power
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Convert upper sideband to power
  states: {}
- name: blocks_complex_to_mag_squared_2
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Convert analog FM signal to power
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: Lower sideband / FM ratio
    type: float
  states: {}
- name: blocks_divide_xx_1
  id: blocks_divide_xx
  parameters:
    comment: Upper sideband / FM ratio
    type: float
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    comment: Digital if either sideband detected (max of both)
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_moving_average_0
  id: blocks_moving_average_xx
  parameters:
    comment: Smooth lower sideband power
    length: energy_avg_len
    max_iter: '4000'
    scale: 1.0/energy_avg_len
    type: float
  states: {}
- name: blocks_moving_average_1
  id: blocks_moving_average_xx
  parameters:
    comment: Smooth upper sideband power
    length: energy_avg_len
    max_iter: '4000'
    scale: 1.0/energy_avg_len
    type: float
  states: {}
- name: blocks_moving_average_2
  id: blocks_moving_average_xx
  parameters:
    comment: Smooth analog FM power
    length: energy_avg_len
    max_iter: '4000'
    scale: 1.0/energy_avg_len
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: Convert to dB (10*log10)
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    comment: Convert to dB (10*log10)
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_2
  id: blocks_nlog10_ff
  parameters:
    comment: Convert FM power to dB (10*log10)
    k: '0'
    n: '10'
  states: {}
- name: blocks_probe_signal_0
  id: blocks_probe_signal_x
  parameters:
    comment: Probe digital indicator for XML-RPC
    type: float
  states: {}
- name: blocks_probe_signal_1
  id: blocks_probe_signal_x
  parameters:
    comment: Probe FM signal level for XML-RPC
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Convert stream to vectors for E2SAR segmenter
    num_items: vlen
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: Check if lower sideband > -20 dB
    high: digital_threshold
    init: '0'
    low: digital_threshold
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    comment: Check if upper sideband > -20 dB
    high: digital_threshold
    init: '0'
    low: digital_threshold
  states: {}
- name: ejfat_e2sar_segmenter_sink_0
  id: ejfat_e2sar_segmenter_sink
  parameters:
    comment: E2SAR Segmenter - segments vectors into EJFAT packets
    data_id: data_id
    event_src_id: event_src_id
    mtu: '9000'
    rate_gbps: '1.0'
    uri: ejfat_uri
    use_cp: 'False'
    vector_size: vlen
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: Filter to FM bandwidth
    cutoff_freq: 90e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_BLACKMAN
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    comment: SDR Source (RTL-SDR, HackRF, etc.)
    freq0: freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Full spectrum view
    fc: '0'
    fftsize: '1024'
    label1: Full Spectrum
    legend: 'False'
    name: '"Full Spectrum"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: Digital sidebands spectrum
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    label1: Lower Sideband
    label2: Upper Sideband
    label3: Analog FM
    name: '"Digital Sidebands"'
    nconnections: '3'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    comment: Display relative power in dB
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Lower Sideband
    label2: Upper Sideband
    max: '0'
    min: '-60'
    name: '"Sideband Power (dB relative to FM)"'
    nconnections: '2'
    type: float
    unit1: dB
    unit2: dB
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    comment: Digital/Analog indicator - False=Analog, True=Digital
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Digital FM
    min: '0'
    type: float
    unit1: (False if {value} == 0 else True)
  states: {}
- name: freq_display
  id: variable_qtgui_label
  parameters:
    comment: Display current frequency
    gui_hint: 2,0,1,2
    label: Frequency (MHz)
    type: real
    value: freq/1e6
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    comment: FM Signal Level Meter
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: FM Signal Level
    max: '0'
    min: '-80'
    type: float
    unit1: dB
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [band_pass_filter_lower, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_lower, '0', qtgui_freq_sink_x_1, '0']
- [band_pass_filter_upper, '0', blocks_complex_to_mag_squared_1, '0']
- [band_pass_filter_upper, '0', qtgui_freq_sink_x_1, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_moving_average_1, '0']
- [blocks_complex_to_mag_squared_2, '0', blocks_moving_average_2, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_divide_xx_1, '0', blocks_nlog10_ff_1, '0']
- [blocks_max_xx_0, '0', blocks_probe_signal_0, '0']
- [blocks_max_xx_0, '0', qtgui_number_sink_1, '0']
- [blocks_moving_average_0, '0', blocks_divide_xx_0, '0']
- [blocks_moving_average_1, '0', blocks_divide_xx_1, '0']
- [blocks_moving_average_2, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_2, '0', blocks_divide_xx_1, '1']
- [blocks_moving_average_2, '0', blocks_nlog10_ff_2, '0']
- [blocks_nlog10_ff_0, '0', blocks_threshold_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_1, '0', blocks_threshold_ff_1, '0']
- [blocks_nlog10_ff_1, '0', qtgui_number_sink_0, '1']
- [blocks_nlog10_ff_2, '0', blocks_probe_signal_1, '0']
- [blocks_nlog10_ff_2, '0', qtgui_number_sink_2, '0']
- [blocks_stream_to_vector_0, '0', ejfat_e2sar_segmenter_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_max_xx_0, '0']
- [blocks_threshold_ff_1, '0', blocks_max_xx_0, '1']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_squared_2, '0']
- [low_pass_filter_0_0, '0', blocks_stream_to_vector_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_1, '2']
- [osmosdr_source_0, '0', band_pass_filter_lower, '0']
- [osmosdr_source_0, '0', band_pass_filter_upper, '0']
- [osmosdr_source_0, '0', low_pass_filter_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
