options:
  parameters:
    description: Receives FM signal from EJFAT source and demodulates
    generate_options: qt_gui
    hier_block_src_path: .:.
    id: fm_receiver_ejfat
    output_language: python
    title: FM Receiver (EJFAT Source)
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: ejfat_file
  id: variable
  parameters:
    value: '"/tmp/fm_stream.bin"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate/5
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: ejfat_ejfat_source
  id: ejfat_ejfat_source
  parameters:
    connected_socket: 'True'
    cpu_cores: ''
    data_id: '0'
    dpv6: 'False'
    ejfat_uri: ''
    event_src_id: '0'
    filename: ejfat_file
    mtu: '1500'
    num_send_sockets: '4'
    rate_gbps: '-1.0'
    repeat: 'True'
    snd_socket_buf_size: '3145728'
    sync_period_ms: '1000'
    sync_periods: '2'
    use_cp: 'True'
    use_ejfat: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    legend: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [ejfat_ejfat_source, '0', qtgui_freq_sink_x_0, '0']
- [ejfat_ejfat_source, '0', qtgui_waterfall_sink_x_0, '0']
- [ejfat_ejfat_source, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
