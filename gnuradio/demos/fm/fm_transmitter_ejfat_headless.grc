options:
  parameters:
    description: Captures FM signal from SDR and streams to EJFAT sink (Headless - no GUI)
    generate_options: no_gui
    hier_block_src_path: .:.
    id: fm_transmitter_ejfat_headless
    output_language: python
    title: FM Transmitter (SDR to EJFAT) - Headless
  states: {}

blocks:
- name: ejfat_file
  id: variable
  parameters:
    value: '"/tmp/fm_stream.bin"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 98.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: ejfat_ejfat_sink
  id: ejfat_ejfat_sink
  parameters:
    filename: ejfat_file
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [low_pass_filter_0, '0', ejfat_ejfat_sink, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
