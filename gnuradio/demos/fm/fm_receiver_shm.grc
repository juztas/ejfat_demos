options:
  parameters:
    description: Receives FM signal from EJFAT SHM source and demodulates
    generate_options: qt_gui
    hier_block_src_path: .:.
    id: fm_receiver_shm
    output_language: python
    title: FM Receiver (EJFAT SHM Source)
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: samp_rate/5
  states: {}
- name: fm_freq
  id: variable
  parameters:
    value: '88.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: shm_name
  id: variable
  parameters:
    value: '"fm_stream"'
  states: {}
- name: vlen
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    comment: |-
      Stereo FM Demodulator with PLL
      Outputs: 0=Left, 1=Right
    deemph_tau: '75e-6'
    quad_rate: channel_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Stereo Audio Output
    num_inputs: '2'
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Left Channel Volume
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Right Channel Volume
    const: volume
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vlen
    type: complex
  states: {}
- name: ejfat_ejfat_shm_source
  id: ejfat_ejfat_shm_source
  parameters:
    shm_name: shm_name
    timeout: '1'
    vlen: vlen
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters:
    comment: |-
      RDS Decoder
      Note: Requires proper RDS signal conditioning
      (57kHz subcarrier extraction, filtering, demodulation)
  states: {state: disabled}
- name: rds_panel_0
  id: rds_panel
  parameters:
    comment: RDS Information Display
    freq: fm_freq
  states: {state: disabled}
- name: rds_parser_0
  id: rds_parser
  parameters:
    comment: RDS Parser
    pty_locale: '1'
  states: {state: disabled}

connections:
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '1']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', rational_resampler_xxx_0, '0']
- [ejfat_ejfat_shm_source, '0', blocks_vector_to_stream_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_pll_0, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
