options:
  parameters:
    description: Captures FM signal from SDR and streams to E2SAR segmenter
    generate_options: qt_gui
    hier_block_src_path: .:.
    id: fm_transmitter_e2sar
    output_language: python
    title: FM Transmitter (SDR to E2SAR)
  states: {}

blocks:
- name: data_id
  id: variable
  parameters:
    comment: E2SAR data ID
    value: '1'
  states: {}
- name: ejfat_uri
  id: variable
  parameters:
    comment: EJFAT URI for E2SAR connection (direct connection, no LB)
    value: '"ejfat://127.0.0.1:19522/lb/1?data=127.0.0.1:19522"'
  states: {}
- name: event_src_id
  id: variable
  parameters:
    comment: E2SAR event source ID
    value: '1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 98.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: vlen
  id: variable
  parameters:
    comment: Vector length - must match receiver
    value: '8192'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Convert stream to vectors for E2SAR segmenter
    num_items: vlen
    type: complex
  states: {}
- name: ejfat_e2sar_segmenter_sink_0
  id: ejfat_e2sar_segmenter_sink
  parameters:
    comment: E2SAR Segmenter - segments vectors into EJFAT packets
    data_id: data_id
    event_src_id: event_src_id
    mtu: '9000'
    rate_gbps: '1.0'
    uri: ejfat_uri
    use_cp: 'False'
    vector_size: vlen
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Filter to FM bandwidth
    cutoff_freq: 90e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_BLACKMAN
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    comment: SDR Source (RTL-SDR, HackRF, etc.)
    freq0: freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', ejfat_e2sar_segmenter_sink_0, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
