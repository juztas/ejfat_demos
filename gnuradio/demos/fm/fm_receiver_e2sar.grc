options:
  parameters:
    description: Receives FM signal from E2SAR reassembler and demodulates
    generate_options: qt_gui
    hier_block_src_path: .:.
    id: fm_receiver_e2sar
    output_language: python
    title: FM Receiver (E2SAR Reassembler)
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: samp_rate/5
  states: {}
- name: data_ip
  id: variable
  parameters:
    comment: Local IP for receiving data packets
    value: '"127.0.0.1"'
  states: {}
- name: ejfat_uri
  id: variable
  parameters:
    comment: EJFAT URI for E2SAR connection
    value: '"ejfat://useless@192.168.100.1:9876/lb/1?sync=192.168.0.1:12345&data=127.0.0.1"'
  states: {}
- name: fm_freq
  id: variable
  parameters:
    value: '88.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: starting_port
  id: variable
  parameters:
    comment: Starting port for receiving E2SAR packets
    value: '19522'
  states: {}
- name: vlen
  id: variable
  parameters:
    comment: Vector length - must match transmitter
    value: '8192'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    comment: |-
      XML-RPC Server for remote control
      Port 8081 (detector uses 8080)
    port: '8081'
  states: {}
- name: snippet_wav_control
  id: snippet
  parameters:
    code: |-
      import pmt

      def set_wav_filename(self, filename):
          """Send filename message to switchable WAV sink."""
          msg = pmt.intern(filename)
          self.switchable_wav_sink_0.to_basic_block()._post(pmt.intern('filename'), msg)
          return True

      self.set_wav_filename = lambda filename: set_wav_filename(self, filename)
    comment: |-
      Adds set_wav_filename() method
      Callable via XML-RPC to switch output files
    section: main_after_init
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '10'
    comment: |-
      Stereo FM Demodulator with PLL
      Outputs: 0=Left, 1=Right
    deemph_tau: '75e-6'
    quad_rate: channel_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Stereo Audio Output
    num_inputs: '2'
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Left Channel Volume
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Right Channel Volume
    const: volume
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    comment: Convert vectors from E2SAR to stream
    num_items: vlen
    type: complex
  states: {}
- name: switchable_wav_sink_0
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.append('.')
      from switchable_wav_sink import switchable_wav_sink
    channels: '2'
    comment: |-
      Custom WAV sink that switches files via messages
      Send filename via XML-RPC
    sample_rate: audio_rate
  states: {}
- name: ejfat_e2sar_reassembler_source_0
  id: ejfat_e2sar_reassembler_source
  parameters:
    comment: E2SAR Reassembler - receives and reassembles EJFAT packets
    data_ip: data_ip
    epoch_ms: '1000'
    event_timeout_ms: '5000'
    kd: '0.0'
    ki: '0.0'
    kp: '0.0'
    max_factor: '2.0'
    min_factor: '0.5'
    num_recv_threads: '1'
    period_ms: '100'
    port_range: '-1'
    rcv_socket_buf_size: '3145728'
    set_point: '0.0'
    starting_port: starting_port
    uri: ejfat_uri
    use_cp: 'False'
    use_host_address: 'False'
    validate_cert: 'True'
    vector_size: vlen
    weight: '1.0'
    with_lb_header: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    legend: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', switchable_wav_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_1, '0', switchable_wav_sink_0, '1']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', rational_resampler_xxx_0, '0']
- [ejfat_e2sar_reassembler_source_0, '0', blocks_vector_to_stream_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_pll_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
