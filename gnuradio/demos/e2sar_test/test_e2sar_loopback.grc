options:
  parameters:
    description: E2SAR Segmenter and Reassembler Test
    generate_options: qt_gui
    hier_block_src_path: .:.
    id: test_e2sar_loopback
    output_language: python
    title: E2SAR Loopback Test
  states: {}

blocks:
- name: data_ip
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {}
- name: data_port
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: ejfat_uri
  id: variable
  parameters:
    value: '"ejfat://token@127.0.0.1:18020/lb/36?data=" + data_ip + ":" + str(data_port)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: signal_freq
  id: variable
  parameters:
    value: '100'
  states: {}
- name: vector_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: |-
      Generate 10 kHz test tone
      (cosine wave)
    freq: signal_freq
    offset: '0.5'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      Convert stream to vectors
      for E2SAR segmenter
    num_items: vector_size
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: |-
      Throttle to sample rate
      to avoid overload
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    comment: |-
      Convert vectors back to stream
      for visualization
    num_items: vector_size
    type: complex
  states: {}
- name: ejfat_e2sar_reassembler_source_0
  id: ejfat_e2sar_reassembler_source
  parameters:
    comment: |-
      E2SAR Reassembler Source
      Receives data from EJFAT
    data_ip: data_ip
    epoch_ms: '1000'
    event_timeout_ms: '5000'
    kd: '0.0'
    ki: '0.0'
    kp: '0.0'
    max_factor: '2.0'
    min_factor: '0.5'
    num_recv_threads: '1'
    period_ms: '100'
    port_range: '-1'
    rcv_socket_buf_size: '3145728'
    set_point: '0.0'
    starting_port: data_port
    uri: ejfat_uri
    use_cp: 'False'
    use_host_address: 'False'
    validate_cert: 'True'
    vector_size: vector_size
    weight: '1.0'
    with_lb_header: 'True'
  states: {}
- name: ejfat_e2sar_segmenter_sink_0
  id: ejfat_e2sar_segmenter_sink
  parameters:
    comment: |-
      E2SAR Segmenter Sink
      Sends data via EJFAT
    data_id: '1285'
    event_src_id: '287454020'
    mtu: '9000'
    rate_gbps: '1.0'
    uri: ejfat_uri
    use_cp: 'False'
    vector_size: vector_size
  states: {}
- name: note_0
  id: note
  parameters:
    note: TRANSMITTER PATH
  states: {}
- name: note_1
  id: note
  parameters:
    note: RECEIVER PATH
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: |-
      Display received signal
      frequency spectrum
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: Received
    name: '"Received Spectrum"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color2: green
    color3: magenta
    color4: red
    comment: |-
      Display received signal
      time domain
    grid: 'True'
    label1: Transmit I
    label2: Transmit Q
    label3: Receive I
    label4: Receive Q
    name: '"Received Signal"'
    nconnections: '4'
    size: '8192'
    srate: samp_rate
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_float_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_float_0_0, '1', qtgui_time_sink_x_0, '3']
- [blocks_stream_to_vector_0, '0', ejfat_e2sar_segmenter_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0, '0']
- [ejfat_e2sar_reassembler_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
